# Keil uVision project PickUpWaring.uvproj, settings and files
target PickUpWaring (ARM-ADS)
  device: NUC029LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: PickUpWaring +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Library\Device\Nuvoton\NUC029xAN\Include;..\Library\CMSIS\Include;..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group CMSIS
    ../Library/Device/Nuvoton/NUC029xAN/Source/: system_NUC029xAN.c
    ../Library/Device/Nuvoton/NUC029xAN/Source/ARM/: startup_NUC029xAN.s
  group User
    ./: BR262_Driver.c detect.c I2C.c main.c delay.c systick.c Buzzer.c ADC_Driver.c WDT_Driver.c 485_Driver.c
  group Library
    ../Library/StdDriver/src/: adc.c clk.c gpio.c i2c.c retarget.c sys.c wdt.c wwdt.c uart.c
